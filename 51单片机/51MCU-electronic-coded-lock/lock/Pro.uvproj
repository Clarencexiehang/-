# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h matrixKey.c MatrixKey.h Delay999ms.c Delay999ms.h
    D:/Code/keil/51pra/lock/: Delay1ms.c Delay1ms.h
